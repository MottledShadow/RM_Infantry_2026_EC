# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --cpp11
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/BSP;../User/Driver;../User/Algorithm;../User/Control;../User/App
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../User/BSP/: bsp.h bsp_debug.c bsp_debug.h bsp_uart.c bsp_uart.h bsp_can.c bsp_can.h bsp_pwm.c bsp_pwm.h bsp_gpio.c bsp_gpio.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h filter.c filter.h bsp_flash.c bsp_flash.h
  group driver
    ../User/Driver/: dt7_driver.c dt7_driver.h motor_driver.c motor_driver.h rsi_driver.c rsi_driver.h vtm_driver.c vtm_driver.h BMI088driver.c BMI088driver.h gyro_calibration.c gyro_calibration.h referee_protocol.c referee_protocol.h
  group algorithm
    ../User/Algorithm/: lpf.c lpf.h key_scan.c key_scan.h pid.c pid.h crc.c crc.h
  group control
    ../User/Control/: gimbal.c gimbal.h friction_wheel.c friction_wheel.h heat_control.c heat_control.h shooter.c shooter.h chassis.c chassis.h
  group application
    ../User/App/: DT7.c DT7.h VTM.c VTM.h referee_ui.c referee_ui.h app.c app.h
software components: CMSIS:CORE 4.3.0
